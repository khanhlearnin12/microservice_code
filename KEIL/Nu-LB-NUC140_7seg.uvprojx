# Keil uVision project Nu-LB-NUC140_7seg.uvprojx, settings and files
target GPIO (6240000::V6.24::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: GPIO_7seg_keypad
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\..\Library\Nu-LB-NUC140\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group Library
    ../../../../Library/StdDriver/src/: gpio.c uart.c clk.c sys.c retarget.c
  group User
    ../: main.c
    ../../../../Library/Nu-LB-NUC140/Source/: SYS_init.c Seven_Segment.c Scankey.c
software components: CMSIS:CORE 5.6.0
